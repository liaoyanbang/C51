# Keil uVision project temp_show.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: temp_show +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\HARDWARE\OLED;..\Project;..\TINY;..\HARDWARE\CHAO;..\HARDWARE\DS18B20
  link misc: REMOVEUNUSED
  group MAIN
    ./: main.c
  group HARDWARE
    ../HARDWARE/CHAO/: ultrasonic_wave.c
    ../HARDWARE/OLED/: oledfont.h oled.c
    ../HARDWARE/DS18B20/: ds18b20.c
  group TINY
    ../TINY/: Conf_tny.A51 RTX51TNY.LIB
