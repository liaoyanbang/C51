# Keil uVision project temp_show.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: temp_show +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\HARDWARE\OLED;..\Project;..\TINY;..\HARDWARE\DS1203;..\HARDWARE\USART;..\HARDWARE\KEY;..\HARDWARE\AT24C02;..\HARDWARE\ADC;..\HARDWARE\IIC;..\HARDWARE\PCF
  link misc: REMOVEUNUSED
  group MAIN
    ./: main.c
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/AT24C02/: AT24C02.c
    ../HARDWARE/ADC/: ADS1015.C
    ../HARDWARE/IIC/: I2C.c
    ../HARDWARE/PCF/: P8563.C
    ../HARDWARE/OLED/: oledfont.h oled.c
  group TINY
    ../TINY/: Conf_tny.A51 RTX51TNY.LIB
