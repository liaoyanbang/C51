# Keil uVision project LM3229.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: LM3229 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源代码组 1
    ./: LM3229.c shuma.c uart.c led.c delay.c iic.c music.c
  group ROT
    ./: Conf_tny.A51 RTX51TNY.LIB
